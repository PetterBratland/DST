# IAR project Main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8E Microchip ATSAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Main.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Microchip\sam3x8\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: at91sam3x8.h core_cm3.h core_cmFunc.h core_cmInstr.h cstartup.s exceptions.c exceptions.h startup_sam3x.c system_sam3x.c system_sam3x.h
  group C-kod
    ./: allLib.c clock.c clock.h display.c display.h initiate.c initiate.h lightsensor.c lightsensor.h linkedList.c linkedList.h main.c mainmenu.c mainmenu.h servo.c servo.h tempSensor.c tempSensor.h
